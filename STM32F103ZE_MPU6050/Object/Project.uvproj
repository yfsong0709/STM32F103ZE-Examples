# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\App;..\..\STM32F103ZE\CMSIS;..\..\STM32F103ZE\Libraries\inc;..\..\STM32F103ZE\Libraries\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: main.c I2C_MPU6050.c kalman.c quaternion.c
  group CMSIS
    ../../STM32F103ZE/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ../../STM32F103ZE/Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../../STM32F103ZE/Startup/: startup_stm32f10x_hd.s
